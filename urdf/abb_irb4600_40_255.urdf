Commit message: adjusting joint 4 + 5 length

File: urdf/abb_irb4600_40_255.urdf (robot description, URDF)
Before this commit: robot abb_irb4600_40_255, 9 links, 8 joints
Joints:
- joint joint_4: origin xyz=0.332 0 0.175 rpy=0 -0 0  -> xyz=0.331 0 0.175 rpy=0 -0 0 
